# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DELAY.c delay.h DS1302.c DS1302.h OLED.c OLED.h I2C.c I2C.h uart.c uart.h ASCII.h port.h public.c public.h text.h ESP8266.c ESP8266.h
